options:
  parameters:
    generate_options: qt_gui
    id: recieve_noise
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '20000000'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    bandwidth: '5000000'
    center_freq: '2480000000'
    samp_rate: '5000000'
    type: fc32
  states: {}

connections:
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
